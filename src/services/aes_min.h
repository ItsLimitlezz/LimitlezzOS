/**
 * Minimal AES-128/256 with an mbedTLS-compatible CTR shim, for the desktop
 * simulator (on the ESP32 the framework's mbedTLS is used instead). Public
 * domain tiny-AES style implementation; correctness-checked against the
 * Meshtastic default-channel test vector at startup is recommended.
 */
#ifndef LZ_AES_MIN_H
#define LZ_AES_MIN_H

#include <stdint.h>
#include <string.h>
#include <stddef.h>

typedef struct { uint8_t round_key[240]; int nr; int nk; } mbedtls_aes_context;

static const uint8_t LZ_SBOX[256] = {
0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16 };

static const uint8_t LZ_RCON[11] = {0x00,0x01,0x02,0x04,0x08,0x10,0x20,0x40,0x80,0x1b,0x36};

static inline void lz_aes_init(mbedtls_aes_context *c) { memset(c, 0, sizeof *c); }
static inline void lz_aes_free(mbedtls_aes_context *c) { (void)c; }

static inline int lz_aes_setkey(mbedtls_aes_context *c, const uint8_t *key, unsigned bits)
{
    c->nk = bits / 32;            /* 4 (128) or 8 (256) */
    c->nr = c->nk + 6;            /* 10 or 14 */
    int nk = c->nk, nr = c->nr;
    uint8_t *rk = c->round_key;
    memcpy(rk, key, 4 * nk);
    for(int i = nk; i < 4 * (nr + 1); i++) {
        uint8_t t[4];
        memcpy(t, rk + 4 * (i - 1), 4);
        if(i % nk == 0) {
            uint8_t tmp = t[0];
            t[0] = LZ_SBOX[t[1]] ^ LZ_RCON[i / nk];
            t[1] = LZ_SBOX[t[2]];
            t[2] = LZ_SBOX[t[3]];
            t[3] = LZ_SBOX[tmp];
        } else if(nk > 6 && i % nk == 4) {
            for(int j = 0; j < 4; j++) t[j] = LZ_SBOX[t[j]];
        }
        for(int j = 0; j < 4; j++) rk[4 * i + j] = rk[4 * (i - nk) + j] ^ t[j];
    }
    return 0;
}

static inline uint8_t lz_xtime(uint8_t x) { return (uint8_t)((x << 1) ^ ((x >> 7) * 0x1b)); }

static inline void lz_aes_encrypt_block(const mbedtls_aes_context *c,
                                        const uint8_t in[16], uint8_t out[16])
{
    uint8_t s[16];
    memcpy(s, in, 16);
    const uint8_t *rk = c->round_key;
    for(int i = 0; i < 16; i++) s[i] ^= rk[i];
    for(int round = 1; round <= c->nr; round++) {
        for(int i = 0; i < 16; i++) s[i] = LZ_SBOX[s[i]];
        uint8_t t;
        t = s[1]; s[1] = s[5]; s[5] = s[9]; s[9] = s[13]; s[13] = t;
        t = s[2]; s[2] = s[10]; s[10] = t; t = s[6]; s[6] = s[14]; s[14] = t;
        t = s[15]; s[15] = s[11]; s[11] = s[7]; s[7] = s[3]; s[3] = t;
        if(round != c->nr) {
            for(int col = 0; col < 4; col++) {
                uint8_t *p = s + 4 * col;
                uint8_t a0 = p[0], a1 = p[1], a2 = p[2], a3 = p[3];
                uint8_t x = a0 ^ a1 ^ a2 ^ a3;
                p[0] ^= x ^ lz_xtime(a0 ^ a1);
                p[1] ^= x ^ lz_xtime(a1 ^ a2);
                p[2] ^= x ^ lz_xtime(a2 ^ a3);
                p[3] ^= x ^ lz_xtime(a3 ^ a0);
            }
        }
        const uint8_t *krk = rk + 16 * round;
        for(int i = 0; i < 16; i++) s[i] ^= krk[i];
    }
    memcpy(out, s, 16);
}

/* mbedTLS-compatible names so mtproto.c can call the same API on both targets */
#define mbedtls_aes_init(c)                 lz_aes_init(c)
#define mbedtls_aes_free(c)                 lz_aes_free(c)
#define mbedtls_aes_setkey_enc(c, k, bits)  lz_aes_setkey((c), (k), (bits))

static inline int mbedtls_aes_crypt_ctr(mbedtls_aes_context *c, size_t len,
                                        size_t *nc_off, uint8_t nonce_counter[16],
                                        uint8_t stream_block[16],
                                        const uint8_t *input, uint8_t *output)
{
    size_t n = *nc_off;
    for(size_t i = 0; i < len; i++) {
        if(n == 0) {
            lz_aes_encrypt_block(c, nonce_counter, stream_block);
            for(int j = 16; j-- > 0; )           /* increment counter, big-endian */
                if(++nonce_counter[j] != 0) break;
        }
        output[i] = input[i] ^ stream_block[n];
        n = (n + 1) & 0x0F;
    }
    *nc_off = n;
    return 0;
}

#endif
